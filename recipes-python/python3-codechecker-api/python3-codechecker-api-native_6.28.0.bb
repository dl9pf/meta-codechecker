SUMMARY = "Recipie to embedded the Python PiP Package codechecker_api"
HOMEPAGE ="https://pypi.org/project/codechecker_api"
LICENSE = "Apache-2.0-with-LLVM-exception"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=4df402de085d59564dd0af78d9b79ec6"

inherit pypi setuptools3 native
PYPI_PACKAGE = "codechecker_api"
SRC_URI[md5sum] = "df2358e84778384ab750b170b0df2444"
SRC_URI[sha256sum] = "b7b7749d38d43026475a34ec5517d7220f1956b8173508a8c7df77e1c1c65a0f"
