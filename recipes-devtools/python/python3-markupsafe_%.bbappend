BBCLASSEXTEND += "native nativesdk"