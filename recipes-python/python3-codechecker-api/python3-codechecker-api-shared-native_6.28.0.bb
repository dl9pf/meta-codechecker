SUMMARY = "Recipie to embedded the Python PiP Package codechecker_api_shared"
HOMEPAGE ="https://pypi.org/project/codechecker_api_shared"
LICENSE = "Apache-2.0-with-LLVM-exception"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=41d616cf1c47865d43db17a7e53175e5"

inherit pypi setuptools3 native
PYPI_PACKAGE = "codechecker_api_shared"
SRC_URI[md5sum] = "dd17b1b27c48d9963f2bc2dd5470403b"
SRC_URI[sha256sum] = "f3f34741f651ae2bc7a01be6908691d7f1c86342f87f1cd60ee88fcd19a7dbab"
